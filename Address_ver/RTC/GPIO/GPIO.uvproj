# Keil uVision project GPIO.uvproj, settings and files
target GPIO (ARM-ADS)
  device: STM32F103C8 STMicroelectronics
  cpu: IRAM(0x20000000-0x20004FFF) IROM(0x8000000-0x800FFFF) CLOCK(8000000) CPUTYPE("Cortex-M3")
  output: GPIO_OUT +hex
  c flags: Optim=1
  c include: .\source;.\STM32F10x
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group source
    ./source/: GPIO_OUT.c STM32_Init.c STM32F10x.s
