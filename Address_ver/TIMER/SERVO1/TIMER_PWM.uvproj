# Keil uVision project TIMER_PWM.uvproj, settings and files
target TIMER_PWM (5060528::V5.06 update 5 (build 528)::ARMCC)
  device: STM32F103RB STMicroelectronics
  cpu: IRAM(0x20000000-0x20004FFF) IROM(0x8000000-0x801FFFF) CLOCK(8000000) CPUTYPE("Cortex-M3")
  output: TIMER_PWM +hex
  c flags: Optim=1 v6Lang=1 v6LangP=1
  c include: .\Initialisation;.\Drivers;.\STM32F10x
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group Initialisation
    ./Initialisation/: STM32F10x.s STM32_Init.c
  group Application
    ./Application/: Timer_pwm.c
