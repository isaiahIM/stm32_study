# Keil uVision project GPIO_STM32F103RCT6_3RD.uvprojx, settings and files
target GPIO (ARM-ADS)
  device: STM32F103RB STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.2.0
  cpu: IROM(0x08000000,0x20000) IRAM(0x20000000,0x5000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: GPIO_STM32F103RCT6_3RD +hex
  c flags: Optim=1 OneElfS=1 wLevel=2
  c include: .\STM32F10x
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group source
    ./source/: GPIO_OUT.c STM32_Init.c STM32F10x.s
